# Keil uVision project balancingCar.uvprojx, settings and files
target balancingCar (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: balancingCar
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/src/: mian.c
  group DEVICE
    ./USER/src/: encoder.c motor.c usart1.c usart2.c usart3.c thread_mw.c JY901.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, RTOS:kernel 3.0.3
